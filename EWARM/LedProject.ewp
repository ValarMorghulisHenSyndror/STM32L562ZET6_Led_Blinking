# IAR project LedProject.ewp, settings and files
configuration LedProject (ARM, debug)
  General.OGChipSelectEditMenu: STM32L562ZE ST STM32L562ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: STM32L562xx
  ICCARM.CCIncludePath2: D:\work_arm_project\LedProject\LedProject\Core\Inc; D:\work_arm_project\LedProject\LedProject\Drivers\STM32L5xx_HAL_Driver\Inc; D:\work_arm_project\LedProject\LedProject\Drivers\CMSIS\Device\ST\STM32L5xx\Include; D:\work_arm_project\LedProject\LedProject\Drivers\CMSIS\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LedProject.hex
  ILINK.IlinkOutputFile: LedProject.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l562xx.s
  group Application/User/Core/inc
    ../Core/Inc/: main.h stm32l5xx_hal_conf.h stm32l5xx_it.h
  group Application/User/Core/src
    ../Core/Src/: main.c stm32l5xx_hal_msp.c stm32l5xx_it.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l5xx.c
  group Drivers/STM32L5xx_HAL_Driver
    ../Drivers/STM32L5xx_HAL_Driver/Src/: stm32l5xx_hal.c stm32l5xx_hal_cortex.c stm32l5xx_hal_dma.c stm32l5xx_hal_dma_ex.c stm32l5xx_hal_exti.c stm32l5xx_hal_flash.c stm32l5xx_hal_flash_ramfunc.c stm32l5xx_hal_gpio.c stm32l5xx_hal_i2c.c stm32l5xx_hal_i2c_ex.c stm32l5xx_hal_icache.c stm32l5xx_hal_pwr.c stm32l5xx_hal_pwr_ex.c stm32l5xx_hal_rcc.c stm32l5xx_hal_rcc_ex.c stm32l5xx_hal_tim.c stm32l5xx_hal_tim_ex.c
